# Keil uVision project STM32F429Demo(LAN+RTOS+MPU6050).uvprojx, settings and files
target STM32F429Demo(LAN+RTOS+MPU6050) (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F429Demo(LAN+RTOS+MPU6050)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;     ../Drivers/CMSIS/Include;    ../Middlewares/Third_Party/LwIP/src/include;    ../Middlewares/Third_Party/LwIP/system;    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;    ../Middlewares/Third_Party/FreeRTOS/Source/include;    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;    ../Middlewares/Third_Party/LwIP/src/include/lwip;    ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;    ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;    ../Middlewares/Third_Party/LwIP/src/include/netif;    ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;    ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;    ../Middlewares/Third_Party/LwIP/src/include/posix;    ../Middlewares/Third_Party/LwIP/src/include/posix/sys;    ../Middlewares/Third_Party/LwIP/system/arch
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c gpio.c stm32f4xx_hal_timebase_TIM.c usart.c lwip.c ethernetif.c i2c.c rtc.c freertos.c tim.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c queue.c croutine.c timers.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c eui64.c chap-md5.c demand.c pppcrypt.c chap-new.c magic.c vj.c ppp.c pppol2tp.c utils.c eap.c upap.c pppos.c pppoe.c ipcp.c ipv6cp.c ecp.c multilink.c fsm.c mppe.c chap_ms.c lcp.c
    ../Middlewares/Third_Party/LwIP/src/core/: dns.c def.c sys.c inet_chksum.c stats.c mem.c memp.c tcp_in.c init.c tcp.c udp.c netif.c pbuf.c lwip_timers.c raw.c tcp_out.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: sha1.c arc4.c md5.c md4.c des.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c api_msg.c err.c sockets.c pppapi.c netdb.c netifapi.c api_lib.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c ip4_addr.c igmp.c autoip.c ip_frag.c icmp.c dhcp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c nd6.c inet6.c ip6.c mld6.c ip6_frag.c dhcp6.c icmp6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
software components: CMSIS:CORE 4.1.0
